## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LD
	bool "ldd"
	help
	  Includes the misc-modules and scull drivers in the roorfs
```
